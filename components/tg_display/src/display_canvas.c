#include "display_canvas.h"
#include <string.h>

/* Five vertical columns per glyph, bit 0 at top. Locally maintained small font. */

/* Icon halves for the high-bit code space: a paired icon occupies two
 * consecutive character cells (code points 0x80+2i and 0x81+2i) and renders
 * 11 pixels wide with the normal one-column gap in the middle. Half glyphs
 * can also stand alone as 5x7 mini icons. Code points 0x90..0xFF are blank. */
static const uint8_t icons[16][5] = {
    /* WIFI 0x80/0x81 */
    {0x00, 0x02, 0x09, 0x15, 0x55}, {0x55, 0x15, 0x09, 0x02, 0x00},
    /* BLE 0x82/0x83 */
    {0x00, 0x00, 0x24, 0x18, 0x7F}, {0x49, 0x2A, 0x14, 0x00, 0x00},
    /* ZB 0x84/0x85 */
    {0x00, 0x00, 0x41, 0x61, 0x51}, {0x49, 0x45, 0x43, 0x41, 0x00},
    /* BAT 0x86/0x87 */
    {0x00, 0x7E, 0x42, 0x5A, 0x5A}, {0x5A, 0x5A, 0x5A, 0x42, 0x3C},
    /* LINK 0x88/0x89 */
    {0x3E, 0x22, 0x2A, 0x2A, 0x36}, {0x36, 0x2A, 0x2A, 0x22, 0x3E},
    /* WARN 0x8A/0x8B */
    {0x41, 0x22, 0x1C, 0x22, 0x41}, {0x00, 0x00, 0x5F, 0x00, 0x00},
    /* HEART 0x8C/0x8D */
    {0x06, 0x0F, 0x1F, 0x3F, 0x7E}, {0x7E, 0x3F, 0x1F, 0x0F, 0x06},
    /* SIG 0x8E/0x8F */
    {0x60, 0x60, 0x00, 0x78, 0x78}, {0x7C, 0x7C, 0x00, 0x7F, 0x7F},
};
static const uint8_t digits[10][5] = {
    {0x3e,0x51,0x49,0x45,0x3e}, {0,0x42,0x7f,0x40,0},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4b,0x31},
    {0x18,0x14,0x12,0x7f,0x10}, {0x27,0x45,0x45,0x45,0x39},
    {0x3c,0x4a,0x49,0x49,0x30}, {1,0x71,9,5,3},
    {0x36,0x49,0x49,0x49,0x36}, {6,0x49,0x49,0x29,0x1e}
};
static const uint8_t letters[26][5] = {
    {0x7e,0x11,0x11,0x11,0x7e}, {0x7f,0x49,0x49,0x49,0x36},
    {0x3e,0x41,0x41,0x41,0x22}, {0x7f,0x41,0x41,0x22,0x1c},
    {0x7f,0x49,0x49,0x49,0x41}, {0x7f,9,9,9,1},
    {0x3e,0x41,0x49,0x49,0x7a}, {0x7f,8,8,8,0x7f},
    {0,0x41,0x7f,0x41,0}, {0x20,0x40,0x41,0x3f,1},
    {0x7f,8,0x14,0x22,0x41}, {0x7f,0x40,0x40,0x40,0x40},
    {0x7f,2,0x0c,2,0x7f}, {0x7f,4,8,0x10,0x7f},
    {0x3e,0x41,0x41,0x41,0x3e}, {0x7f,9,9,9,6},
    {0x3e,0x41,0x51,0x21,0x5e}, {0x7f,9,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {1,1,0x7f,1,1},
    {0x3f,0x40,0x40,0x40,0x3f}, {0x1f,0x20,0x40,0x20,0x1f},
    {0x3f,0x40,0x38,0x40,0x3f}, {0x63,0x14,8,0x14,0x63},
    {7,8,0x70,8,7}, {0x61,0x51,0x49,0x45,0x43}
};

static void glyph(unsigned char c, uint8_t out[5])
{
    memset(out, 0, 5);
    if (c >= 0x80) {
        /* Icon code space; undefined halves (0x90..0xFF) render blank. */
        if (c < 0x80 + sizeof(icons) / sizeof(icons[0]))
            memcpy(out, icons[c - 0x80], 5);
        return;
    }
    if (c >= 'a' && c <= 'z') c -= 'a' - 'A';
    if (c >= 'A' && c <= 'Z') { memcpy(out, letters[c-'A'], 5); return; }
    if (c >= '0' && c <= '9') { memcpy(out, digits[c-'0'], 5); return; }
    switch (c) {
    case ' ': return;
    case '.': out[2]=0x60; return;
    case ',': out[2]=0x60; out[1]=0x80; return;
    case ':': out[2]=0x36; return;
    case '-': memset(out, 8, 5); return;
    case '_': memset(out, 0x40, 5); return;
    case '/': out[0]=0x20; out[1]=0x10; out[2]=8; out[3]=4; out[4]=2; return;
    case '+': memset(out, 8, 5); out[2]=0x3e; return;
    case '%': out[0]=0x63; out[1]=0x13; out[2]=8; out[3]=0x64; out[4]=0x63; return;
    default: out[0]=2; out[1]=1; out[2]=0x51; out[3]=9; out[4]=6; return;
    }
}

bool tg_canvas_pixel(uint8_t *buffer, uint16_t x, uint16_t y, bool on)
{
    if (!buffer || x >= 128 || y >= 64) return false;
    unsigned index = (y / 8) * 128 + x;
    uint8_t mask = (uint8_t)(1u << (y % 8));
    if (on) buffer[index] |= mask;
    else buffer[index] &= (uint8_t)~mask;
    return true;
}

bool tg_canvas_line(uint8_t *buffer, uint8_t row, const char *text)
{
    if (!buffer || !text || row >= 8) return false;
    uint8_t *line = buffer + row * 128;
    memset(line, 0, 128); /* Replacing a shorter line erases the old tail. */
    for (unsigned col = 0; col < 21 && text[col]; ++col) {
        glyph((unsigned char)text[col], line + col * 6);
    }
    return true;
}
